PACKAGECONFIG_append = " accessibility eglfs fontconfig tslib linuxfb"
PACKAGECONFIG_remove = "examples tests"

PACKAGECONFIG_append_pn-qtbase = " sql-sqlite"

#DEPENDS += "userland"
